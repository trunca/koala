CXXFLAGS_append_su980 += " -std=c++11 -fPIC -fno-strict-aliasing "
