SRC_URI_remove_su980 += "file://Using-PKG_CHECK_MODULES-to-found-headers-and-libraries.patch"
